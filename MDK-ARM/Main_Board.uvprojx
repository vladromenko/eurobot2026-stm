# Keil uVision project Main_Board.uvprojx, settings and files
target Main_Board (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Main_Board +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_FULL_LL_DRIVER,ARM_MATH_CM4,__FPU_PRESENT=1U
  c include: ../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Drivers\CMSIS\DSP\Include;..\Middlewares\FreeRTOS-Kernel;..\Middlewares\FreeRTOS-Kernel\include;..\Middlewares\FreeRTOS-Kernel\portable\RVDS\ARM_CM4F;..\Core\App\Include;..\Core\BSP\Include;..\Core\Lib\Include;..\Core\OS_Tasks\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\STM32F407.sct
  group MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver*LL
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_utils.c
  group Middlewares/FreeRTOS-Kernel
    ../Middlewares/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/FreeRTOS-Kernel/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/CMSIS/DSP
    ../Drivers/CMSIS/DSP/Source/MatrixFunctions/: arm_mat_add_f32.c arm_mat_cmplx_mult_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_mult_f32.c arm_mat_scale_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
    ../Drivers/CMSIS/DSP/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
    ../Drivers/CMSIS/DSP/Source/CommonTables/: arm_common_tables.c
  group Core/App
    ../Core/App/: bus_device.c kinematics.c main.c odometry.c robot_behavior_routine.c robot_gpio_config.c stm32f4xx_it.c system_stm32f4xx.c terminal.c terminal_cmd_handlers.c debug_terminal.c debug_terminal_cmd_handlers.c
  group Core/BSP
    ../Core/BSP/: board_gpio_config.c board_hw_config.c l6474_drvr.c pwm.c spi_gpo.c usartx_communication.c usartx_timeout.c stepper.c ws2812b.c
  group Core/Lib
    ../Core/Lib/: bms_board.c button.c dynamixel_ax.c dynamixel_master.c dynamixel_mx.c fifo_routine.c h_bridge.c maxon.c rc_servo.c serial.c hl_rtu.c
  group Core/OS_Tasks
    ../Core/OS_Tasks/: buttons_callback_task.c buttons_poll_task.c demo_task.c freertos_routine_plug.c game_task.c odometry_task.c terminal_task.c stepper_task.c debug_task.c
software components: CMSIS:CORE 5.6.0
